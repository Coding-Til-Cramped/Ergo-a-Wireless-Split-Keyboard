# Repository Coding-Til-Cramped/Ergo-a-Wireless-Split-Keyboard

File README.md:

# Split60 a Wireless Split Keyboard

A low profile, wireless, 60 key ergonomic split keyboard made for long typing or coding sessions controlled by 2 nice nanos and runs on ZMK Firmware

# Features

fully wireless connectivity

low profile switches

ergonomic layout

# Cad model 

I have a case and believe me that the pcb fits in the case i have done the mesurements the case is in 4 parts the top and bottom bolt togeter (i already have the screws)

Case top view:

Case Side view:

PCB:

Blender Render:

# PCB 

I made this in kicad it usese hot swappable switches and two pro micros

# Firmware 

This keyboard will use ZMK firmware

# BOM

All from typeractive

60x Kailh Choc v1 Low Profile Switches:

2x Nice Nano v2.0:

2x Machine Sockets and Pins:

2x Battery Jack

60x SMD Diodes

60x Kailh Hotswap Sockets

2x Power Switch

2x Lithium Battery 110mAh

---------------------------------------------------------------------

i have made the cost lots better by using ally express it is now only 97 usd

## KiCad design PCB/left_side.kicad_pcb

Board: 2 copper layers, 115.8 x 104.0 mm, 64 parts (0 on the bottom side), 45 nets.

Parts:
B1: Panasonic_EVQPUL_EVQPUC
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: ComboDiode
JST1: JST_PH_S2B-PH-K_02x2.00mm_Angled
MCU1: nice_nano
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16, S17, S18, S19, S20, S21, S22, S23, S24, S25, S26, S27, S28, S29, S30: PG1350
T1: SPDT_C128955

Connections:
GND: B1.1, JST1.2, MCU1.3, MCU1.4, MCU1.23
P002: D2.1, D6.1, D14.1, D18.1, D25.1, D28.1, MCU1.18
P011: MCU1.10, S21.1, S22.1, S23.1, S24.1, S25.1
P017: MCU1.5, S26.1, S27.1, S28.1, S29.1, S30.1
P020: MCU1.6, S1.1, S2.1, S3.1, S4.1, S5.1
P022: MCU1.7, S6.1, S7.1, S8.1, S9.1, S10.1
P024: MCU1.8, S11.1, S12.1, S13.1, S14.1, S15.1
P029: D3.1, D7.1, D11.1, D19.1, D24.1, D30.1, MCU1.19
P031: D8.1, D12.1, D15.1, D20.1, D23.1, D27.1, MCU1.20
P100: MCU1.9, S16.1, S17.1, S18.1, S19.1, S20.1
P113: D1.1, D4.1, D9.1, D16.1, D21.1, D29.1, MCU1.16
P115: D5.1, D10.1, D13.1, D17.1, D22.1, D26.1, MCU1.17
RAW: MCU1.24, T1.2
RST: B1.2, MCU1.22
fifth_bottom: D17.2, S22.2
fifth_home: D18.2, S23.2
fifth_mod: D16.2, S21.2
fifth_num: D20.2, S25.2
fifth_top: D19.2, S24.2
first_bottom: D26.2, S2.2
first_home: D2.2, S3.2
first_mod: D1.2, S1.2
first_num: D27.2, S5.2
first_top: D3.2, S4.2
fourth_bottom: D13.2, S17.2
fourth_home: D14.2, S18.2
fourth_mod: D29.2, S16.2
fourth_num: D15.2, S20.2
fourth_top: D30.2, S19.2
pos: JST1.1, T1.1
second_bottom: D5.2, S7.2
second_home: D6.2, S8.2
second_mod: D4.2, S6.2
second_num: D8.2, S10.2
second_top: D7.2, S9.2
sixth_bottom: D22.2, S27.2
sixth_home: D25.2, S28.2
sixth_mod: D21.2, S26.2
sixth_num: D23.2, S30.2
sixth_top: D24.2, S29.2
third_bottom: D10.2, S12.2
third_home: D28.2, S13.2
third_mod: D9.2, S11.2
third_num: D12.2, S15.2
third_top: D11.2, S14.2

## Commit log

2026-01-15 Enhance README with features and BOM details
    Expanded the README with detailed features, PCB information, firmware, and BOM.
2026-01-15 Revise BOM with updated pricing and formatting
    Updated the BOM section to reflect accurate pricing and removed redundant entries.
2026-01-22 Revise BOM pricing and cost savings
    Updated pricing information and improved cost details.
2026-01-25 Include Blender Render section in README
    Added Blender render image to README.
2026-01-28 Update keyboard name and firmware in README
